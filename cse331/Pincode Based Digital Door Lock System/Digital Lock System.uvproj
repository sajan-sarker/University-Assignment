# Keil uVision project Digital Lock System.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS80C51 ISSI
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(40000000)
  output: Digital Lock System +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: digital_lock_system.c
